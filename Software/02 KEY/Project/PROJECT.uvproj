# Keil uVision project PROJECT.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: PROJECT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Bsp\delay;..\Bsp\led;..\Bsp\key
  group User
    ./: STARTUP.A51
    ../User/: main.c
  group Bsp
    ../Bsp/delay/: delay.c
    ../Bsp/led/: led.c
    ../Bsp/key/: key.c
