# Keil uVision project PROJECT.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: PROJECT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Bsp\delay;..\Bsp\led;..\Bsp\key;..\Bsp\timer;..\Bsp\uart;..\Bsp\at24cxx
  group User
    ./: STARTUP.A51
    ../User/: stc_it.c main.c
  group Bsp
    ../Bsp/delay/: delay.c
    ../Bsp/led/: led.c
    ../Bsp/key/: key.c
    ../Bsp/timer/: timer.c
    ../Bsp/uart/: uart.c
    ../Bsp/at24cxx/: at24cxx.c at24cxx_i2c.c
